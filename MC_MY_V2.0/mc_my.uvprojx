# Keil uVision project mc_my.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LKS32MC034FLF6Q8B Linko
  pack: Linko.LKS03x.1.1.8
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: mc_my +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\vendor\LKS32MC03x_Periph_Driver\Include;.\include\app;.\include\bsp;.\include\mcs;.\CMSIS\HAll;D:\Keil_v5\ARM\INC\Linko\LKS32MC03x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER_APP
    ./src/user/: main.c interrupt.c manage.c user_app.c app_uart_comm.c app_control.c app_height.c
  group User_Include
    ./include/app/: Constant.h main.h Prototype.h Type.h Variable.h
  group MCS
    ./src/mcs/: mcs_init.c mcs_error_handling.c mcs_control.c mcs_foc_hw.c mcs_task.c mcs_motor.c mcs_hall.c sensorless_ctrl.c mcs_math.c mcs_pwm_foc.c
  group MCS_Include
    ./include/mcs/: mcs_prototype.h mcs_include.h mcs_state_type.h mcs_ctrl_type.h mcs_variable.h mcs_error_type.h mcs_foc_hw_type.h mcs_motor_type.h mcs_bp_customer.h mcs_const.h
  group BSP
    ./src/bsp/: hardware_init.c
    ./include/bsp/: bsp_user.h
  group Periph
    ./vendor/LKS32MC03x_Periph_Driver/Source/: lks32mc03x_adc.c lks32mc03x_cmp.c lks32mc03x_dac.c lks32mc03x_DMA.c lks32MC03x_Flash.c lks32mc03x_gpio.c lks32mc03x_hall.c lks32mc03x_i2c.c lks32mc03x_IWDG.c lks32mc03x_MCPWM.c lks32mc03x_nvr.lib lks32mc03x_spi.c lks32mc03x_sys.c lks32mc03x_timer.c lks32mc03x_tmp.c lks32mc03x_uart.c startup_lks32mc03x.s
  group HALL
    ./CMSIS/HAll/: HallAngle.h LKS03x_StdMCS2_HALLV003p6.lib
